RPIFW_SRC_URI = "https://github.com/raspberrypi/firmware/archive/master.zip"
RPIFW_S = "${WORKDIR}/firmware-master"
SRC_URI[sha256sum] = "82217c6e4224f79eef4e84533d8651bf320682c051237e5c6ddbf5ef0ea3b385"
SRC_URI[md5sum] = "6429faae548cd0ad7016a1c1d1ba5991"
